# Keil uVision project AT8236.uvprojx, settings and files
target Tb6612demo (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWER\MOTO;..\HAREWER\PWM;..\HAREWER\GPIO;..\HAREWER\ADC;..\HAREWER\ENCODER;..\HAREWER\SERVO;..\HAREWER\ULTRASONIC;..\HAREWER\LINEWALKING;..\HAREWER\IRAVOID;..\HAREWER\bsp;..\HAREWER\PS2_Control;..\HAREWER\THREE_LINEWALKING;..\HAREWER\wit_c_sdk;..\SYSTEM\USART2;..\HAREWER\JY61P
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/USART2/: UART2.c
  group HAREWER
    ../HAREWER/bsp/: bsp.c
    ../HAREWER/MOTO/: moto.c
    ../HAREWER/PWM/: pwm.c
    ../HAREWER/ADC/: adc.c
    ../HAREWER/ENCODER/: encoder.c
    ../HAREWER/SERVO/: servo.c
    ../HAREWER/LINEWALKING/: linewalking.c
    ../HAREWER/IRAVOID/: iravoid.c
    ../HAREWER/PS2_Control/: ps2_control.c
    ../HAREWER/THREE_LINEWALKING/: three_linewalking.c
    ../HAREWER/wit_c_sdk/: wit_c_sdk.c
    ../HAREWER/JY61P/: JY61P.c
